#include "AccStep.h"

unsigned short New_AccStep[ACC_STEP_NUM] =      // 加速曲线数组
{
	0,3,3,4,4,4,4,4,4,4,4,5,5,5,5,5,5,5,6,6,6,6,6,6,7,7,7,7,7,8,8,8,8,9,9,9,9,10,10,10,
	11,11,11,12,12,12,13,13,13,14,14,15,15,16,16,16,17,17,18,18,19,20,20,21,21,22,23,23,
	24,25,25,26,27,28,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,46,47,48,49,51,
	52,54,55,57,58,60,61,63,64,66,68,70,72,73,75,77,79,81,83,85,88,90,92,94,97,99,101,104,
	106,109,111,114,117,119,122,125,128,131,133,136,139,142,146,149,152,155,158,162,165,168,
  171,175,178,182,185,189,192,196,199,203,207,210,214,218,221,225,229,233,236,240,244,248,
	251,255,259,262,266,270,274,277,281,285,288,292,296,299,303,307,310,314,317,321,324,327,
	331,334,337,341,344,347,350,353,357,360,363,366,368,371,374,377,380,382,385,388,390,393,
	395,398,400,403,405,407,410,412,414,416,418,420,422,424,426,428,430,431,433,435,437,438,
	440,441,443,444,446,447,449,450,451,453,454,455,456,458,459,460,461,462,463,464,465,466,
	467,468,469,470,471,471,472,473,474,474,475,476,477,477,478,478,479,480,480,481,481,482,
	482,483,483,484,484,485,485,486,486,486,487,487,488,488,488,489,489,489,490,490,490,490,
	491,491,491,492,492,492,492,492,493,493,493,493,494,494,494,494,494,494,495,495,495,495,
	495,495,495,496,496,496,496,496,496,496,496,497,497
};

void Process_Key_Speed(uint8_t key_pressed, KeySpeedCtrl_t *ctrl)
{
    // 1. 双击检测状态机 (仅在按下瞬间触发)
    if(key_pressed && !ctrl->last_state)
		{ 
			if(ctrl->dc_timer > 0)	ctrl->is_full_speed = 1;// 计时器未清零时再次按下 -> 判定为双击，开启全速
			else
			{
				// 第一次按下 -> 默认半速，并启动计时器
        ctrl->is_full_speed = 0;
        ctrl->dc_timer = DOUBLE_CLICK_TICKS;
      }
    }
    
    // 记录本次状态供下次比较
    ctrl->last_state = key_pressed;

    // 2. 计时器递减
    if(ctrl->dc_timer > 0)	ctrl->dc_timer--;
    // 3. 确定当前的最大速度限制
    int16_t current_max_step = ctrl->is_full_speed ? MAX_STEP_FULL : MAX_STEP_HALF;

    // 4. 平滑加减速逻辑
    if(key_pressed)
		{
			// 如果按下按键：加速直到达到当前上限
      if(ctrl->t_val < current_max_step)	ctrl->t_val++;
      // 重点：如果在全速减速过程中重新单按(要求变半速)，让其平滑降到半速，而不是瞬间急刹
      else if(ctrl->t_val > current_max_step)	ctrl->t_val--;
    }
		else ctrl->t_val = 0;// 如果松开按键：平滑减速到0

    // 安全限幅防溢出
    if(ctrl->t_val >= MAX_STEP_FULL) ctrl->t_val = MAX_STEP_FULL;
    if(ctrl->t_val <= 0)	ctrl->t_val = 0;

    // 5. 映射到加速曲线
    ctrl->out_speed = New_AccStep[ctrl->t_val];
}


